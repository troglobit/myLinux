## user/Kconfig
```kconfig
menu "User Defined Programs"

config USER_HELLO
       bool "hello - Hello World example program"


endmenu
```
